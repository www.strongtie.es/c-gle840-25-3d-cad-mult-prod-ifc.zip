Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:43:32
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:43:32 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{11B7A4AB-B100-4A34-B27F-D8F66C465EB6}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:43:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:43:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:43:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE840_66_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0; Line Weight: 1

# IfcBuildingElementProxy: C_GLE840_66_25_3D_CAD_MULT_Prod, C_GLE840_66_25_3D_CAD_MULT_Prod:C_GLE840_66_25_3D_CAD_MULT_Prod:195474
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00660443 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/66/2.5
Identity Data - Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; ObjectType: GLE840/66/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Model ID: 0253753702738360917401852503615459694953; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Title: Wood Connectors; Model: GLE840/66/2.5; Name: GLE840/66/2.5; Description: Joist hanger; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu
General - Reference: GLE840/66/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.49; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
