Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:43:36
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:43:36 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B05A540E-B33D-4376-AD9C-42B11AE9FCB1}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:43:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:43:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:43:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE840_78_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Graphics - Symbol at End 2 Default: yes; Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GLE840_78_25_3D_CAD_MULT_Prod, C_GLE840_78_25_3D_CAD_MULT_Prod:C_GLE840_78_25_3D_CAD_MULT_Prod:199242
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00660443 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/78/2.5
Identity Data - Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Model ID: 0253753702738360917401852503615459694953; URL: www.strongtie.eu; ObjectType: GLE840/78/2.5; Manufacturer: Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; Name: GLE840/78/2.5; UniClass Title: Joist hangers; Model: GLE840/78/2.5; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.49; Reference: GLE840/78/2.5
Materials and Finishes - Product Material: Galvanised
