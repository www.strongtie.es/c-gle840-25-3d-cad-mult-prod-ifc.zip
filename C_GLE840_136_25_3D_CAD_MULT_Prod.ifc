Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:44:00
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:44:00 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{984099AC-BCD4-4BED-A9B2-0B0014AF870D}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:43:59 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:44:00 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:44:00 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE840_136_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GLE840_136_25_3D_CAD_MULT_Prod, C_GLE840_136_25_3D_CAD_MULT_Prod:C_GLE840_136_25_3D_CAD_MULT_Prod:217454
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00660443 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/136/2.5
Materials and Finishes - Product Material: Galvanised
Identity Data - Product Type: Joist hanger; Copyright: ©Simpson Strong-Tie; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; Model: GLE840/136/2.5; URL: www.strongtie.eu; Description: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Title: Joist hangers; UniClass Number: Pr_20_29_31_44; OmniClass Number: 23.20.40.11.24.14; Model ID: 0253753702738360917401852503615459694953; Name: GLE840/136/2.5; ObjectType: GLE840/136/2.5
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE840/136/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.49; EPD: https://www.strongtie.eu/eu-EU/EPD
