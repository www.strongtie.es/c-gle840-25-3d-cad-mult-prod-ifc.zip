Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-12T14:43:54
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 14:43:54 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{8437437F-4694-48BD-A699-C5B5786FB6B1}\ifc * Database version: 5507 * Database creation date: Thu Oct 12 14:43:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 14:43:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 14:43:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Normal Holes\RFA 3D\C_GLE840_122_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GLE840_122_25_3D_CAD_MULT_Prod, C_GLE840_122_25_3D_CAD_MULT_Prod:C_GLE840_122_25_3D_CAD_MULT_Prod:213058
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00660443 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE840/122/2.5
Identity Data - Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Name: GLE840/122/2.5; Model ID: 0253753702738360917401852503615459694953; Model: GLE840/122/2.5; URL: www.strongtie.eu; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; ObjectType: GLE840/122/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE840/122/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.49
Materials and Finishes - Product Material: Galvanised
